# Keil uVision project TEMPLATE.uvprojx, settings and files
target TEMPLATE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\0_CORE;..\..\1_FWLIB_3_5_0\inc;..\..\3_PROJECT;..\..\2_DRIVE\Common;..\..\2_DRIVE\Common\DELAY;..\..\2_DRIVE\USART;..\..\2_DRIVE\OneWire;..\..\4_SENSORS;..\..\2_DRIVE\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../../0_CORE/: core_cm3.c
    ../../0_CORE/startup/: startup_stm32f10x_md.s
  group USER
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB_3_5_0
    ../../1_FWLIB_3_5_0/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group DRIVE
    ../../2_DRIVE/Common/DELAY/: delay.c
    ../../2_DRIVE/USART/: usart.c
    ../../2_DRIVE/OneWire/: OneWire.c
    ../../2_DRIVE/LED/: led.c
  group Sensors
    ../../4_SENSORS/: DHTxx.c
